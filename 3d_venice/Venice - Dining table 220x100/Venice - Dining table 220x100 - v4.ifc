Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Venice - Dining table 220x100 - v4.ifc
Time: 2023-11-10T14:57:28
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (9)
Name
 | Venice - Dining table 220x100_4 - ObjectType: SketchupGroup
 | Venice - Dining table 220x100_8 - ObjectType: SketchupGroup
 | Venice - Dining table 220x100_7 - ObjectType: SketchupGroup
 | Venice - Dining table 220x100_3 - ObjectType: SketchupGroup
 | Venice - Dining table 220x100_0 - ObjectType: SketchupGroup
 | Venice - Dining table 220x100_5 - ObjectType: SketchupGroup
 | Venice - Dining table 220x100_2 - ObjectType: SketchupGroup
 | Venice - Dining table 220x100_6 - ObjectType: SketchupGroup
 | Venice - Dining table 220x100_1 - ObjectType: SketchupGroup
